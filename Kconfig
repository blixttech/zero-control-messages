## Kconfig
```kconfig
config ZERO_CONTROL_MESSAGES
    bool "Use nanopb-based message structures for control messages"
    default y
```
